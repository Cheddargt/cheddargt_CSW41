# IAR project Lab5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TX_ENABLE_IAR_LIBRARY_SUPPORT
  ICCARM.CCIncludePath2: ..\..\ThreadX\common\inc; ..\..\ThreadX\ports\cortex_m4\iar\inc; ..; ..\..\TivaWare_C_Series-2.2.0.295; ..\inc; ..\..\..\..\common\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Lab5.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Tiva.icf
  ILINK.IlinkAdditionalLibs: C:\Users\lucas\Documents\UTFPR\Semestre\Sistemas Embarcados\LucasLeyser\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a; C:\Users\lucas\Documents\UTFPR\Semestre\Sistemas Embarcados\LucasLeyser\ThreadX\ports\cortex_m4\iar\example_build\Debug\Exe\tx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: sample_threadx.c startup_ewarm.c tx_initialize_low_level.s
