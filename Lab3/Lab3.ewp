# IAR project Lab3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\TivaWare_C_Series-2.2.0.295
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: Lab3.bin
  ILINK.IlinkOutputFile: Lab2.out
  ILINK.IlinkIcfFile: Tiva.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: images.c Lab3.s top_level.c
  group Libraries
    ../../TivaWare_C_Series-2.2.0.295/driverlib/ewarm/Exe/: driverlib.a
  group Source
    src/: startup_ewarm.c
